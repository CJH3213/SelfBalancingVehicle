# Keil uVision project SelfBalancingVehicle.uvprojx, settings and files
target SelfBalancingVehicle (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SelfBalancingVehicle +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MyFiles/HardwareDriver/Include;../MyFiles/FunctionalModle/Include;../MyFiles/StaticData/OLED12832;../MyFiles/HardwareDriver/MPU6050/eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group HardwareDriver
    ../MyFiles/HardwareDriver/OLED12832/: oled.c
    ../MyFiles/HardwareDriver/Motors/: Motors.c
    ../MyFiles/HardwareDriver/MPU6050/: mpu6050.c
    ../MyFiles/HardwareDriver/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MyFiles/HardwareDriver/BLE_HC09/: BLE_HC09.c
    ../MyFiles/HardwareDriver/KEY/: Key.c
    ../MyFiles/HardwareDriver/Battery/: Battery.c
  group FunctionalModule
    ../MyFiles/FunctionalModle/Delay/: Delay.c
    ../MyFiles/FunctionalModle/Protocol/: Protocol.c
    ../MyFiles/FunctionalModle/SerialPort/: SerialPort.c
    ../MyFiles/FunctionalModle/BalanceControl/: BalanceControl.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
